## nemu/configs/riscv64-am_defconfig
```kconfig
# CONFIG_ISA_riscv64=y
CONFIG_RV64=y
CONFIG_TARGET_AM=y
# CONFIG_TRACE is not set
CONFIG_MSIZE=0xf000000
CONFIG_DEVICE=y
```
